# Keil uVision project practica2.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s SWI.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c
  group Conecta 4
    ./: celda.h tableros.h conecta4_2022.c conecta4_2022.h
  group Colas
    ./: cola_eventos.c cola_eventos.h eventos.h cola_msg.c cola_msg.h msg.h cola_buffer.c cola_buffer.h
  group Perifericos
    ./: tiempo.c tiempo.h gpio.c gpio.h power.h power.c boton.h boton.c pll.s irq_control.h uart.c uart.h
  group Gestores
    ./: G_Alarm.c G_Alarm.h G_Energia.c G_Energia.h G_IO.c G_IO.h G_Boton.c G_Boton.h G_serie.c G_serie.h alarmas.h
