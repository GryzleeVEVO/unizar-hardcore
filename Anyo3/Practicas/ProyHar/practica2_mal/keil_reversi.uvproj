# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c Power_management.c Power_management.h boton_eint0.c boton_eint0.h timer0.c timer0.h botones.h reversi8.h botones.c Tiner.h pulsacion.h Timer.h pulsacion.c Time.c reversi8.c
  group Modified
    ./: temporizador.c eventos.h cola_asyn.h cola_asyn.c temporizador.h
